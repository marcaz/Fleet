# Keil uVision project fleet.uvproj, settings and files
target FLEET (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: fleet +hex
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX MANGUSTA_DISCOVERY USE_USB_OTG_FS HSE_VALUE=8000000
  c include: ..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Lib\ARM;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\headers;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\sources\USB;..\headers\GPS;..\headers\Modem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ../sources/: system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_it.c
  group Peripherals
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_dma.c
  group main
    ../sources/: main.c RTX_Conf_CM.c acc_api.c acc_driver.c leds.c uart_api.c uart_driver.c
  group Modem
    ../sources/Modem/: phone_api.c phone_com.c phone_sms_sending.c phone_tools.c phone_zip.c
  group GPS
    ../sources/GPS/: nmea_api.c nmea_data.c
